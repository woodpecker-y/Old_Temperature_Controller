# IAR project Backup of Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_HD; USE_FULL_ASSERT; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LCD; HAVE_DBG; HAVE_BEEP; HAVE_KEY; HAVE_FLASH_EXT; HAVE_SHT2x
  ICCSTM8.CCIncludePath2: ..\User\inc; ..\Board\; ..\Lib\include\bsp\; ..\Lib\include\hal\; ..\Lib\include\Libraries\; ..\Lib\include\; ..\Lib\include\Module\; ..\Lib\include\Utili\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BA2804-EV.hex
  ILINK.IlinkOutputFile: TempCollector.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\Lib\ADF.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; USE_FULL_ASSERT; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LCD; HAVE_DBG; HAVE_BEEP; HAVE_RFID; HAVE_KEY
  OBJCOPY.OOCOutputFile: LockingValve-1.1.0.160630.hex
  ILINK.IlinkOutputFile: Project.out
  group Board
    ../Board/: board.c board.h
  group Docs
    ../Docs/: README.txt
  group Lib
    ../Lib/: ADF.a
    ../User/inc/: cj188.h disp.h error.h menu.h modbus.h protocol.h sysparams.h task.h task_adc.h task_config.h task_disp.h task_key.h task_list.h task_main.h task_report.h task_rf.h
    ../Lib/include/HAL/: utili.h
  group User
    ../User/src/: cj188.c disp.c error.c main.c menu.c modbus.c protocol.c stm8l15x_it.c sysparams.c task_adc.c task_config.c task_disp.c task_key.c task_main.c task_report.c task_rf.c tesk.c verify.c
